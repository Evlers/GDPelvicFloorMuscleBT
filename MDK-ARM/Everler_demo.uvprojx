# Keil uVision project Everler_demo.uvprojx, settings and files
target STM32F103xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Everler_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,NDEBUG
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\APP;..\DRIVE;..\FATFS;..\HAL;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\DRIVE\MPU;..\RTT;..\utility;..\utility\libcrc\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c booster.c train.c impulse.c log.c fun.c
  group DRIVE
    ../DRIVE/: delay.c hal.c ble.c ble_commun.c cfSensor.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group HAL
    ../HAL/: hal_adc.c hal_flash.c hal_i2c.c hal_rtc.c hal_time.c hal_usart.c hal_spi.c hal_sys.c hal_buzzer.c hal_key.c
  group LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: stm32f10x_it.c system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group utility
    ../utility/: utility.c
  group utility/libcrc
    ../utility/libcrc/src/: crc8.c
software components: CMSIS:CORE 5.2.0
